# Keil uVision project LY-STM32.uvprojx, settings and files
target LY-STM32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LY-STM32 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\Lib\inc;.\System;.\USR
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group ASM
    ./ASM/: startup_stm32f10x_hd.s
  group USR
    ./USR/: main.c pbdata.c stm32f10x_it.c
  group Lib
    ./Lib/SRC/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c
  group System
    ./System/: core_cm3.c system_stm32f10x.c
